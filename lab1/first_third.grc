options:
  parameters:
    author: Admin
    generate_options: qt_gui
    id: first_third
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: five
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: four
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: one
  id: variable_qtgui_range
  parameters:
    label: k1
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: three
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: two
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '500'
    low_cutoff_freq: '20'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '30'
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '6000'
    low_cutoff_freq: '3000'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '30'
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_2
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '15000'
    low_cutoff_freq: '9000'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '30'
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_3
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '3000'
    low_cutoff_freq: '500'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '30'
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_4
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '9000'
    low_cutoff_freq: '6000'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '30'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: one
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: three
    type: float
  states: {}
- name: blocks_multiply_const_vxx_3
  id: blocks_multiply_const_vxx
  parameters:
    const: five
    type: float
  states: {}
- name: blocks_multiply_const_vxx_4
  id: blocks_multiply_const_vxx
  parameters:
    const: two
    type: float
  states: {}
- name: blocks_multiply_const_vxx_5
  id: blocks_multiply_const_vxx
  parameters:
    const: four
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\Admin\Downloads\Bach.wav
    repeat: 'True'
  states: {}

connections:
- [band_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [band_pass_filter_1, '0', blocks_multiply_const_vxx_1, '0']
- [band_pass_filter_2, '0', blocks_multiply_const_vxx_3, '0']
- [band_pass_filter_3, '0', blocks_multiply_const_vxx_4, '0']
- [band_pass_filter_4, '0', blocks_multiply_const_vxx_5, '0']
- [blocks_add_xx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '4']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0, '2']
- [blocks_multiply_const_vxx_3, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_4, '0', blocks_add_xx_0, '3']
- [blocks_multiply_const_vxx_5, '0', blocks_add_xx_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_1, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_2, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_3, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_4, '0']

metadata:
  file_format: 1
